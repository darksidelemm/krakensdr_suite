options:
  parameters:
    author: KrakenRF Inc.
    copyright: 2026 KrakenRF Inc.
    description: KrakenSDR v2 MUSIC DoA
    generate_options: qt_gui
    id: kraken_music_doa
    output_language: python
    title: KrakenSDR v2 MUSIC DoA
  states: {}

blocks:
- name: decim
  id: variable_qtgui_range
  parameters:
    comment: |-
      Runtime-adjustable: the FIRs run at full rate (decim=1) with taps
      tracking this value; the actual rate cut happens in keep_one_in_n,
      whose set_n works at runtime (a FIR's decimation factor does not).
    gui_hint: (1,0,1,2)
    label: Decimation
    rangeType: int
    start: '1'
    step: '1'
    stop: '48'
    value: '10'
  states: {}
- name: fir_taps
  id: variable
  parameters:
    comment: |-
      Anti-alias low-pass, tracks decim: cutoff 40% / transition 20%
      of the decimated output rate (decim=24 -> 40 kHz / 20 kHz)
    value: firdes.low_pass(1.0, samp_rate, 0.4*samp_rate/decim, 0.2*samp_rate/decim)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Every change triggers a heimdall retune + recalibration cycle
    gui_hint: (0,0,1,3)
    label: Center Frequency [MHz]
    start: '24'
    step: '0.1'
    stop: '1766'
    value: '100.0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,3,1,3)
    label: Gain [dB] (-1 = AGC)
    start: '-1'
    step: '0.1'
    stop: '49.6'
    value: '40.2'
  states: {}
- name: array_type
  id: variable_qtgui_chooser
  parameters:
    comment: Applied live - doa_music regenerates its steering vectors
    gui_hint: (1,4,1,2)
    label: Array Type
    label0: UCA
    label1: ULA
    num_opts: '2'
    option0: '"UCA"'
    option1: '"ULA"'
    type: string
    value: '"UCA"'
  states: {}
- name: radius
  id: variable_qtgui_entry
  parameters:
    comment: Applied live - doa_music regenerates its steering vectors
    gui_hint: (1,2,1,2)
    label: UCA Radius / ULA Spacing [m]
    type: real
    value: '0.25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: ch0_decim_fft
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    comment: CH0 decimated spectrum (the band MUSIC actually sees)
    fc: freq*1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tab_decimated@0: (0,0,1,1)'
    legend: 'False'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: ch0_decim_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decim
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: 'tab_decimated@0: (1,0,1,1)'
    int_max: '-20'
    int_min: '-120'
    type: complex
  states: {}
- name: ch0_full_fft
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: CH0 full 2.4 MHz spectrum (straight from the source)
    fc: freq*1e6
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tab_full_spectrum@0: (0,0,1,1)'
    legend: 'False'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: ch0_full_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '1024'
    gui_hint: 'tab_full_spectrum@0: (1,0,1,1)'
    int_max: '-20'
    int_min: '-120'
    type: complex
  states: {}
- name: doa_angle_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (3,0,1,3)
    label1: DoA [deg]
    max: '360'
    min: '0'
    type: float
  states: {}
- name: doa_conf_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (3,3,1,3)
    label1: Confidence
    min: '0'
    type: float
  states: {}
- name: doa_music_0
  id: krakensdr_v2_doa_music
  parameters:
    array_dist: radius
    array_type: array_type
    freq: freq
    num_elements: '5'
    signal_dimension: '1'
    vec_len: vec_len
  states: {}
- name: doa_spectrum_sink
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: (2,0,1,6)
    legend: 'False'
    name: '"MUSIC Pseudospectrum"'
    vlen: '360'
    x_axis_label: '"Angle [deg]"'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: fir_ch0
  id: fir_filter_xxx
  parameters:
    comment: |-
      Full-rate filter (decim here is fixed at construction);
      the rate cut happens in keep_ch0 so the slider works live
    decim: '1'
    taps: fir_taps
    type: ccf
  states: {}
- name: fir_ch1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccf
  states: {}
- name: fir_ch2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccf
  states: {}
- name: fir_ch3
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccf
  states: {}
- name: fir_ch4
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: fir_taps
    type: ccf
  states: {}
- name: keep_ch0
  id: blocks_keep_one_in_n
  parameters:
    comment: Runtime decimation (set_n)
    n: decim
    type: complex
  states: {}
- name: keep_ch1
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: complex
  states: {}
- name: keep_ch2
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: complex
  states: {}
- name: keep_ch3
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: complex
  states: {}
- name: keep_ch4
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: complex
  states: {}
- name: krakensdr_v2_source_0
  id: krakensdr_v2_krakensdr_source
  parameters:
    coherent_only: 'True'
    ctrl_port: '8092'
    data_port: '8091'
    dc_correction: 'True'
    debug: 'False'
    freq: freq
    gain: gain
    ip_addr: 127.0.0.1
    num_channels: '5'
  states: {}
- name: s2v_ch0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch3
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch4
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: tab_decimated
  id: qtgui_tab_widget
  parameters:
    comment: Labeled container - the tab text is the visible title
    gui_hint: (4,3,1,3)
    label0: CH0 Decimated (the band MUSIC sees)
    num_tabs: '1'
  states: {}
- name: tab_full_spectrum
  id: qtgui_tab_widget
  parameters:
    comment: Labeled container - the tab text is the visible title
    gui_hint: (4,0,1,3)
    label0: CH0 Full Spectrum (2.4 MHz)
    num_tabs: '1'
  states: {}

connections:
- [doa_music_0, '0', doa_spectrum_sink, '0']
- [doa_music_0, '1', doa_angle_sink, '0']
- [doa_music_0, '2', doa_conf_sink, '0']
- [fir_ch0, '0', keep_ch0, '0']
- [fir_ch1, '0', keep_ch1, '0']
- [fir_ch2, '0', keep_ch2, '0']
- [fir_ch3, '0', keep_ch3, '0']
- [fir_ch4, '0', keep_ch4, '0']
- [keep_ch0, '0', ch0_decim_fft, '0']
- [keep_ch0, '0', ch0_decim_waterfall, '0']
- [keep_ch0, '0', s2v_ch0, '0']
- [keep_ch1, '0', s2v_ch1, '0']
- [keep_ch2, '0', s2v_ch2, '0']
- [keep_ch3, '0', s2v_ch3, '0']
- [keep_ch4, '0', s2v_ch4, '0']
- [krakensdr_v2_source_0, '0', ch0_full_fft, '0']
- [krakensdr_v2_source_0, '0', ch0_full_waterfall, '0']
- [krakensdr_v2_source_0, '0', fir_ch0, '0']
- [krakensdr_v2_source_0, '1', fir_ch1, '0']
- [krakensdr_v2_source_0, '2', fir_ch2, '0']
- [krakensdr_v2_source_0, '3', fir_ch3, '0']
- [krakensdr_v2_source_0, '4', fir_ch4, '0']
- [s2v_ch0, '0', doa_music_0, '0']
- [s2v_ch1, '0', doa_music_0, '1']
- [s2v_ch2, '0', doa_music_0, '2']
- [s2v_ch3, '0', doa_music_0, '3']
- [s2v_ch4, '0', doa_music_0, '4']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
