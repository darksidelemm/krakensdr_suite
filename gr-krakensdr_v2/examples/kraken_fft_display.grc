options:
  parameters:
    author: KrakenRF Inc.
    copyright: 2026 KrakenRF Inc.
    description: KrakenSDR v2 FFT Display
    generate_options: qt_gui
    id: kraken_fft_display
    output_language: python
    title: KrakenSDR v2 FFT Display
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0)
    label: Center Frequency [MHz]
    type: real
    value: '100.0'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,1)
    label: Gain [dB] (neg = AGC)
    type: real
    value: '40.2'
  states: {}
- name: krakensdr_v2_source_0
  id: krakensdr_v2_krakensdr_source
  parameters:
    ip_addr: 127.0.0.1
    data_port: '8091'
    ctrl_port: '8092'
    num_channels: '5'
    freq: freq
    gain: gain
    coherent_only: 'True'
    dc_correction: 'True'
    debug: 'False'
  states: {}
- name: qtgui_sink_ch0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: (1,0)
    name: '"ch_0"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_ch1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: (1,1)
    name: '"ch_1"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_ch2
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: (2,0)
    name: '"ch_2"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_ch3
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: (2,1)
    name: '"ch_3"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_ch4
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq*1e6
    fftsize: '16384'
    gui_hint: (3,0)
    name: '"ch_4"'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [krakensdr_v2_source_0, '0', qtgui_sink_ch0, '0']
- [krakensdr_v2_source_0, '1', qtgui_sink_ch1, '0']
- [krakensdr_v2_source_0, '2', qtgui_sink_ch2, '0']
- [krakensdr_v2_source_0, '3', qtgui_sink_ch3, '0']
- [krakensdr_v2_source_0, '4', qtgui_sink_ch4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
