options:
  parameters:
    author: KrakenRF Inc.
    copyright: 2026 KrakenRF Inc.
    description: KrakenSDR v2 Correlation Check
    generate_options: qt_gui
    id: kraken_correlator_test
    output_language: python
    title: KrakenSDR v2 Correlation Check
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '16384'
  states: {}
- name: fft_cut
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0)
    label: Center Frequency [MHz]
    type: real
    value: '100.0'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,1)
    label: Gain [dB] (neg = AGC)
    type: real
    value: '40.2'
  states: {}
- name: krakensdr_v2_source_0
  id: krakensdr_v2_krakensdr_source
  parameters:
    ip_addr: 127.0.0.1
    data_port: '8091'
    ctrl_port: '8092'
    num_channels: '5'
    freq: freq
    gain: gain
    coherent_only: 'False'
    dc_correction: 'True'
    debug: 'False'
  states: {}
- name: s2v_ch0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch3
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: s2v_ch4
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: corr_01
  id: krakensdr_v2_correlator
  parameters:
    vec_len: vec_len
    fft_cut: fft_cut
  states: {}
- name: xcorr_sink_01
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (1,0)
    legend: 'False'
    name: '"XCorr CH0xCH1"'
    vlen: fft_cut
    x_axis_label: '"Lag [samples]"'
    x_start: '-fft_cut//2'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: phase_sink_01
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (1,1)
    max: '180'
    min: '-180'
    type: float
    label1: Phase 0-1 [deg]
  states: {}
- name: lag_sink_01
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (1,2)
    max: '100'
    min: '-100'
    type: float
    label1: Lag 0-1 [samp]
  states: {}
- name: corr_02
  id: krakensdr_v2_correlator
  parameters:
    vec_len: vec_len
    fft_cut: fft_cut
  states: {}
- name: xcorr_sink_02
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (2,0)
    legend: 'False'
    name: '"XCorr CH0xCH2"'
    vlen: fft_cut
    x_axis_label: '"Lag [samples]"'
    x_start: '-fft_cut//2'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: phase_sink_02
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (2,1)
    max: '180'
    min: '-180'
    type: float
    label1: Phase 0-2 [deg]
  states: {}
- name: lag_sink_02
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (2,2)
    max: '100'
    min: '-100'
    type: float
    label1: Lag 0-2 [samp]
  states: {}
- name: corr_03
  id: krakensdr_v2_correlator
  parameters:
    vec_len: vec_len
    fft_cut: fft_cut
  states: {}
- name: xcorr_sink_03
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (3,0)
    legend: 'False'
    name: '"XCorr CH0xCH3"'
    vlen: fft_cut
    x_axis_label: '"Lag [samples]"'
    x_start: '-fft_cut//2'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: phase_sink_03
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (3,1)
    max: '180'
    min: '-180'
    type: float
    label1: Phase 0-3 [deg]
  states: {}
- name: lag_sink_03
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (3,2)
    max: '100'
    min: '-100'
    type: float
    label1: Lag 0-3 [samp]
  states: {}
- name: corr_04
  id: krakensdr_v2_correlator
  parameters:
    vec_len: vec_len
    fft_cut: fft_cut
  states: {}
- name: xcorr_sink_04
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (4,0)
    legend: 'False'
    name: '"XCorr CH0xCH4"'
    vlen: fft_cut
    x_axis_label: '"Lag [samples]"'
    x_start: '-fft_cut//2'
    x_step: '1.0'
    y_axis_label: '"dB"'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: phase_sink_04
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (4,1)
    max: '180'
    min: '-180'
    type: float
    label1: Phase 0-4 [deg]
  states: {}
- name: lag_sink_04
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: (4,2)
    max: '100'
    min: '-100'
    type: float
    label1: Lag 0-4 [samp]
  states: {}

connections:
- [krakensdr_v2_source_0, '0', s2v_ch0, '0']
- [krakensdr_v2_source_0, '1', s2v_ch1, '0']
- [krakensdr_v2_source_0, '2', s2v_ch2, '0']
- [krakensdr_v2_source_0, '3', s2v_ch3, '0']
- [krakensdr_v2_source_0, '4', s2v_ch4, '0']
- [s2v_ch0, '0', corr_01, '0']
- [s2v_ch1, '0', corr_01, '1']
- [corr_01, '0', xcorr_sink_01, '0']
- [corr_01, '1', phase_sink_01, '0']
- [corr_01, '2', lag_sink_01, '0']
- [s2v_ch0, '0', corr_02, '0']
- [s2v_ch2, '0', corr_02, '1']
- [corr_02, '0', xcorr_sink_02, '0']
- [corr_02, '1', phase_sink_02, '0']
- [corr_02, '2', lag_sink_02, '0']
- [s2v_ch0, '0', corr_03, '0']
- [s2v_ch3, '0', corr_03, '1']
- [corr_03, '0', xcorr_sink_03, '0']
- [corr_03, '1', phase_sink_03, '0']
- [corr_03, '2', lag_sink_03, '0']
- [s2v_ch0, '0', corr_04, '0']
- [s2v_ch4, '0', corr_04, '1']
- [corr_04, '0', xcorr_sink_04, '0']
- [corr_04, '1', phase_sink_04, '0']
- [corr_04, '2', lag_sink_04, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
